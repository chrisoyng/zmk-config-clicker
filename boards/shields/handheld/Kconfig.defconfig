## boards/shields/handheld/Kconfig.defconfig
```kconfig
if SHIELD_HANDHELD

config ZMK_KEYBOARD_NAME
    default "handheld"

endif # SHIELD_HANDHELD
```
